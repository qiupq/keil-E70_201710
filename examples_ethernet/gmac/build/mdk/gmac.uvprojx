# Keil uVision project gmac.uvprojx, settings and files
target sram (ARM-ADS)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-V_DFP.1.0.0
  cpu: IROM(0x00400000,0x00200000) IRAM(0x20400000,0x00060000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: gmac
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: BOARD_SAME70_XPLD __SAME70Q21__ sram MPU_HAS_NOCACHE_REGION TRACE_LEVEL=4
  c include: ..\..\;..\..\..\..\libraries\libchip;..\..\..\..\libraries\libchip\include;..\..\..\..\libraries\libchip\include\same70;..\..\..\..\libraries\libchip\include\cmsis\CMSIS\Include;..\..\..\..\libraries\libboard;..\..\..\..\libraries\libboard\include
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: ..\..\..\..\libraries\libboard\resources_e70\nocache_region\mdk\sram.sct
  link misc: --diag_suppress=L6314
  group application
    ../../../../libraries/libboard/resources_e70/mdk/: workaround.s
    ../../: main.c MiniIp.c
  group libchip
    ../../../../libraries/libchip/source/: exceptions.c mpu.c pio.c pio_it.c pmc.c supc.c tc.c timetick.c uart.c wdt.c xdma_hardware_interface.c xdmac.c xdmad.c gmac.c gmacd.c twi.c twid.c
    ../../../../libraries/libboard/resources_e70/mdk/: retarget.c startup_sam.c
    ../../../../libraries/libboard/resources_e70/: system_same70.c
  group libboard
    ../../../../libraries/libboard/source/: board_lowlevel.c board_memories.c dbg_console.c led.c trace.c gmacb_phy.c
target flash (ARM-ADS)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-V_DFP.1.0.0
  cpu: as above
  output: gmac
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: BOARD_SAME70_XPLD __SAME70Q21__ flash MPU_HAS_NOCACHE_REGION TRACE_LEVEL=4
  c include: as above
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: ..\..\..\..\libraries\libboard\resources_e70\nocache_region\mdk\flash.sct
  link misc: --diag_suppress=L6314
